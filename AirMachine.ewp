# IAR project AirMachine.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1230C3PM TexasInstruments TM4C1230C3PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1; RT_DEBUG_SUPPORT; I2C_DEVICE_SUPPORT; WIFI_DEVICE_SUPPORT; xZIGBEE_DEVICE_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: include; src\ac; driverlib; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: AirMachine.bin
  ILINK.IlinkOutputFile: AirMachine.out
  ILINK.IlinkIcfFile: AirMachine.icf
  ILINK.IlinkAdditionalLibs: driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Inc
    src/ac/: ac_api.h ac_cfg.h ac_common.h ac_hal.h ac_protocol_interface.h
    include/: bmd.h common.h Iot_Fan.h Iot_I2c.h Iot_Key.h Iot_Lcd.h Iot_Led.h Iot_Pm25.h Iot_Pwm.h Iot_Sht21.h Iot_T6603.h Iot_Timer.h Iot_Uart.h types.h
  group Source
    src/ac/: ac_api.c ac_common.c ac_hal.c crc.c
    src/: Iot_Fan.c Iot_I2c.c Iot_Key.c Iot_Lcd.c Iot_Ntc.c Iot_Pm25.c Iot_Pwm.c Iot_Sht21.c Iot_T6603.c Iot_Timer.c main.c startup_ewarm.c uartstdio.c
    src/uart/: Iot_Uart.c
