<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Inc</name>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_api.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_cfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_hal.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_protocol_interface.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\bmd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\common.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Fan.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_I2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Key.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Lcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Led.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Pm25.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Pwm.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Sht21.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_T6603.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Timer.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\Iot_Uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\include\types.h</name>
    </file>
  </group>
  <group>
    <name>Libraries</name>
  </group>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_api.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_common.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\ac_hal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\ac\crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Fan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_I2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Key.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Ntc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Pm25.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Pwm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Sht21.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_T6603.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\Iot_Timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\uart\Iot_Uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\startup_ewarm.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\uartstdio.c</name>
    </file>
  </group>
</project>


